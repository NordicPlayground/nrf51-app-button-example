# Keil uVision project nrf51-app-button-example.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10028 NRF51 DEBUG
  c misc: --c99
  c include: ..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c
  group Documentation
    ../../: Abstract.txt license.txt
  group ::Device
    RTE/Device/nRF51422_xxAC/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_Drivers
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/2.0.0/hal/: nrf_delay.c
  group ::nRF_Libraries
    RTE/nRF_Libraries/nRF51422_xxAC/: app_error.c app_error.h app_gpiote.c app_gpiote.h app_util_platform.c app_button.c app_button.h app_timer.c app_timer.h app_scheduler.c app_scheduler.h nrf_assert.c nrf_assert.h app_timer_appsh.c app_timer_appsh.h
software components: CMSIS:CORE 3.40.0, Board Support:bsp 8.0.0, Device:Startup 7.1.0, nRF_Drivers:nrf_delay 2.0.0, nRF_Drivers:nrf_error 2.0.0, nRF_Drivers:nrf_gpio 2.0.0, nRF_Drivers:nrf_gpiote 2.0.0, nRF_Libraries:app_button 2.0.0, nRF_Libraries:app_error 2.0.0, nRF_Libraries:app_gpiote 2.0.0, nRF_Libraries:app_scheduler 2.0.0, nRF_Libraries:app_timer 2.0.0, nRF_Libraries:app_timer_with_app_scheduler 2.0.0, nRF_Libraries:app_util 2.0.0, nRF_Libraries:nrf_assert 2.0.0
